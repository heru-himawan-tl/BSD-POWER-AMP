.title 1300W RMS FOR 4-OHMS CLASS-TD AUDIO POWER AMPLIFIER - DEVELOPMENT STEP 6
.include "spice_models/model.lib"
R_TMPL1 VPOUT LOAD_OUT 4
R_LOAD1 LOAD_OUT 0 4
V102 +120V 0 DC 120V
R_RELAY1 +24V PTC_RL 660
R_GND1 INPUT_GND 0 1
V105 0 -15V DC 15V
V103 0 -120V DC 120V
V104 +15V 0 DC 15V
V106 +24V 0 DC 24V
V101 MAIN_IN 0 dc 0 ac 1.44 sin(0 1.44 1k 0 0)
Q602 +120V Net-_C602-Pad2_ Net-_D604-Pad1_ MJE340
C602 +120V Net-_C602-Pad2_ 330pF
R601 +120V Net-_D601-Pad1_ 1.5k
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
R605 +120V Net-_D605-Pad2_ 47k
Q603 +120V Net-_D605-Pad2_ Net-_D606-Pad1_ MJE340
R606 VSTDRVP2 VSAVP 56
Q605 VSTCP VSTDRVP2 VSAVP 2SC5200
R604 VSTDRVP1 VSAVP 470
D602 DRVP2 Net-_C601-Pad2_ BAV21
R602 Net-_C601-Pad1_ Net-_C602-Pad2_ 47k
D603 Net-_D603-Pad1_ Net-_C602-Pad2_ 1N4734
Q604 +120V VSTDRVP1 VSTDRVP2 MJE15032
D606 Net-_D606-Pad1_ VSTDRVP1 1N4007
R603 Net-_C601-Pad2_ 0 47k
Q601 0 Net-_C601-Pad2_ Net-_D603-Pad1_ 2N5401
C601 Net-_C601-Pad1_ Net-_C601-Pad2_ 10uF
D604 Net-_D604-Pad1_ VSTDRVP1 1N4007
D605 0 Net-_D605-Pad2_ 1N4744
Q410 VSAVP DRVP1 DRVP2 2SC5200
D609 Net-_D609-Pad1_ +120V 1N4742
Q606 VSTAP Net-_Q606-Pad2_ +120V 2N5401
R611 VSLDRVP VSGZP 1.5k
R610 VSLDRVP 0 15k
R609 Net-_D609-Pad1_ 0 15k
D610 VSFP VSLDRVP BAV21
Q607 VSLDRVP Net-_D609-Pad1_ VSTAP 2N5401
Q4131 VSAVN DRVN2 Net-_Q4131-Pad3_ 2SA1943
Q4132 VSAVN DRVN2 Net-_Q4132-Pad3_ 2SA1943
R4272 VMOUT Net-_Q4132-Pad3_ 0.33
R4271 VMOUT Net-_Q4131-Pad3_ 0.33
R4273 VMOUT Net-_Q4133-Pad3_ 0.33
R4274 VMOUT Net-_Q4134-Pad3_ 0.33
R4275 VMOUT Net-_Q4135-Pad3_ 0.33
Q4133 VSAVN DRVN2 Net-_Q4133-Pad3_ 2SA1943
Q4135 VSAVN DRVN2 Net-_Q4135-Pad3_ 2SA1943
Q4134 VSAVN DRVN2 Net-_Q4134-Pad3_ 2SA1943
R4262 Net-_Q4122-Pad3_ VMOUT 0.33
Q4121 VSAVP DRVP2 Net-_Q4121-Pad3_ 2SC5200
R4261 Net-_Q4121-Pad3_ VMOUT 0.33
Q4122 VSAVP DRVP2 Net-_Q4122-Pad3_ 2SC5200
Q4123 VSAVP DRVP2 Net-_Q4123-Pad3_ 2SC5200
R4264 Net-_Q4124-Pad3_ VMOUT 0.33
R4265 Net-_Q4125-Pad3_ VMOUT 0.33
R4263 Net-_Q4123-Pad3_ VMOUT 0.33
Q4124 VSAVP DRVP2 Net-_Q4124-Pad3_ 2SC5200
Q4125 VSAVP DRVP2 Net-_Q4125-Pad3_ 2SC5200
R4241 DRVP2 VMOUT 7.5
R4251 VMOUT DRVN2 7.5
Q411 VSAVN DRVN1 DRVN2 2SA1943
R608 Net-_Q606-Pad2_ VSTCP 150
D608 Net-_D607-Pad2_ VSTCP MURF1560
R607 +120V VSTCP 1.5
D607 +120V Net-_D607-Pad2_ MURF1560
Q409 -120V VASN DRVN1 MJE15033
R4231 DRVP1 DRVN1 220
Q408 +120V VASP DRVP1 MJE15032
R704 VSAVN VSTDRVN1 470
R706 VSAVN VSTDRVN2 56
D702 Net-_C701-Pad1_ DRVN2 BAV21
R703 0 Net-_C701-Pad1_ 47k
R705 Net-_D705-Pad1_ -120V 47k
Q702 -120V Net-_C702-Pad1_ Net-_D704-Pad2_ MJE350
R701 Net-_D701-Pad2_ -120V 1.5k
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
D704 VSTDRVN1 Net-_D704-Pad2_ 1N4007
Q703 -120V Net-_D705-Pad1_ Net-_D706-Pad2_ MJE350
D706 VSTDRVN1 Net-_D706-Pad2_ 1N4007
D705 Net-_D705-Pad1_ 0 1N4744
C702 Net-_C702-Pad1_ -120V 330pF
D703 Net-_C702-Pad1_ Net-_D703-Pad2_ 1N4734
C701 Net-_C701-Pad1_ Net-_C701-Pad2_ 10uF
R702 Net-_C702-Pad1_ Net-_C701-Pad2_ 47k
Q701 0 Net-_C701-Pad1_ Net-_D703-Pad2_ 2N5551
D707 Net-_D707-Pad1_ -120V MURF1560
R707 VSTCN -120V 1.5
Q705 VSTCN VSTDRVN2 VSAVN 2SA1943
Q704 -120V VSTDRVN1 VSTDRVN2 MJE15033
R708 VSTCN Net-_Q706-Pad2_ 150
D708 VSTCN Net-_D707-Pad1_ MURF1560
Q610 +120V VSGZP Net-_Q608-Pad3_ 2N5551
Q609 VSFP Net-_Q608-Pad3_ VSGP MJE350
Q611 +120V Net-_Q608-Pad3_ VSGP MJE340
Q608 VSFP VSLDRVP Net-_Q608-Pad3_ 2N5401
D611 VSFP VSGZP 1N4742
C603 VSZPP VSAVP 2200pF
R612 VSFP VSZPP 680
D614 0 VSAVP MURF1560
C604 VSAVP 0 1uF
D612 0 VSFP MURF1560
Q4126 VSAVP DRVP2 Net-_Q4126-Pad3_ 2SC5200
R4266 Net-_Q4126-Pad3_ VMOUT 0.33
L401 VMOUT VPOUT 1uH
R428 VMOUT Net-_C408-Pad1_ 10
Q4136 VSAVN DRVN2 Net-_Q4136-Pad3_ 2SA1943
R4276 VMOUT Net-_Q4136-Pad3_ 0.33
C408 Net-_C408-Pad1_ 0 0.1uF
D615 VSAVP +120V MURF1560
D613 VSFP +120V MURF1560
L601 VSFP VSAVP 10uH
XQ6012 +120V VSGP VSFP IRFP250N
XQ6011 +120V VSGP VSFP IRFP250N
D406 +120V Net-_D405-Pad1_ 1N4007
C410 +120V 0 10uF
D409 Net-_D409-Pad1_ 0 1N4007
R4111 VASGCTLP Net-_D409-Pad1_ 560
R401 Net-_C401-Pad2_ REF 560
C401 MAIN_IN Net-_C401-Pad2_ 10uF
C409 +120V 0 0.1uF
R407 Net-_D405-Pad2_ 0 100k
D405 Net-_D405-Pad1_ Net-_D405-Pad2_ 1N4007
C411 0 -120V 0.1uF
D402 Net-_D401-Pad2_ OP 1N4007
D401 Net-_D401-Pad1_ Net-_D401-Pad2_ 1N4007
C404 Net-_C404-Pad1_ Net-_C404-Pad2_ 27pF
XU401 unconnected-_U401-Pad1_ NFB REF -15V Net-_C404-Pad2_ OP +15V Net-_C404-Pad1_ NE5534
C402 INPUT_GND REF 220pF
R421 Net-_R421-Pad1_ Net-_Q407-Pad2_ 560
R420 VASP Net-_Q407-Pad2_ 560
D403 OP Net-_D403-Pad2_ 1N4007
R406 Net-_D401-Pad1_ Net-_D404-Pad2_ 1k
R4021 INPUT_GND REF 20k
D411 VASGCTLP Net-_D411-Pad2_ 1N4007
C405 VASP Net-_C405-Pad2_ 270pF
Q403 Net-_C405-Pad2_ Net-_D401-Pad1_ VASGCTLP MJE340
R422 VASP Net-_R421-Pad1_ 2k
RT401 VASP Net-_R421-Pad1_ 5k
R4121 VASGCTLP VASP 20k
R4041 NFB Net-_C403-Pad1_ 270
C403 Net-_C403-Pad1_ INPUT_GND 220uF
C412 0 -120V 10uF
R405 INPUT_GND 0 10
Q401 Net-_D401-Pad1_ Net-_D405-Pad2_ Net-_Q401-Pad3_ MJE350
R4081 +120V Net-_Q401-Pad3_ 100
D410 Net-_D410-Pad1_ Net-_C405-Pad2_ 1N4007
R4131 +120V Net-_D410-Pad1_ 180
Q404 VASP Net-_C405-Pad2_ VAS_EDP MJE350
R4141 +120V VAS_EDP 180
D414 Net-_D411-Pad2_ VASGCTLN 1N4007
C406 VASP VASN 0.1uF
R419 Net-_Q407-Pad2_ VASN 1.8k
Q407 VASN Net-_Q407-Pad2_ VASP MJE350
R4161 VASN VASGCTLN 20k
R4151 VASGCTLN Net-_D412-Pad2_ 560
Q405 Net-_C407-Pad2_ Net-_D404-Pad2_ VASGCTLN MJE350
D413 Net-_C407-Pad2_ Net-_D413-Pad2_ 1N4007
R4171 Net-_D413-Pad2_ -120V 180
D412 0 Net-_D412-Pad2_ 1N4007
C407 VASN Net-_C407-Pad2_ 270pF
Q406 VASN Net-_C407-Pad2_ VAS_EDN MJE340
R4181 VAS_EDN -120V 180
D408 Net-_D407-Pad2_ -120V 1N4007
R4101 Net-_Q402-Pad3_ -120V 100
D407 Net-_D407-Pad1_ Net-_D407-Pad2_ 1N4007
Q402 Net-_D404-Pad2_ Net-_D407-Pad1_ Net-_Q402-Pad3_ MJE340
D404 Net-_D403-Pad2_ Net-_D404-Pad2_ 1N4007
R409 0 Net-_D407-Pad1_ 100k
R4031 VMOUT NFB 20k
Q708 -120V VSLDRVN Net-_Q708-Pad3_ 2N5401
Q710 VSFN VSGZN Net-_Q708-Pad3_ 2N5551
Q706 VSTAN Net-_Q706-Pad2_ -120V 2N5551
Q709 -120V Net-_Q708-Pad3_ VSGN MJE350
Q711 VSFN Net-_Q708-Pad3_ VSGN MJE340
D710 -120V VSGZN 1N4742
D711 VSGZN VSFN BAV21
R710 0 VSGZN 15k
R709 0 VSTAN 15k
XQ7011 VSFN VSGN -120V IRFP250N
XQ7012 VSFN VSGN -120V IRFP250N
D713 -120V VSFN MURF1560
D715 -120V VSAVN MURF1560
L701 VSFN VSAVN 10uH
Q707 VSLDRVN VSTAN -120V 2N5551
D709 VSGZN VSLDRVN BAV21
D712 VSFN 0 MURF1560
R711 VSZPN VSFN 680
C703 VSAVN VSZPN 2200pF
C704 0 VSAVN 1uF
D714 VSAVN 0 MURF1560
S901 LOAD_OUT VPOUT +24V PTC_RL sw1 ON
R915 Net-_D911-Pad2_ PTC_REF 100k
D911 Net-_C904-Pad2_ Net-_D911-Pad2_ 1N4148
R916 PTC_OP Net-_D913-Pad2_ 4.7k
D914 PTC_RL +24V 1N4002
D910 PTC_REF +15V 1N4148
D907 Net-_D907-Pad1_ PTC_REF 1N4148
Q903 PTC_RL Net-_D913-Pad2_ 0 TIP41C
C904 PTC_RL Net-_C904-Pad2_ 10uF
D912 0 Net-_C904-Pad2_ 1N4148
D913 0 Net-_D913-Pad2_ 1N4148
R913 Net-_R912-Pad2_ PTC_REF 470
R912 +15V Net-_R912-Pad2_ 15k
R914 PTC_REF -15V 15k
D909 -15V Net-_D908-Pad1_ 1N4148
XU901 Net-_D907-Pad1_ Net-_R909-Pad1_ Net-_C903-Pad1_ -15V Net-_D908-Pad1_ PTC_REF PTC_OP +15V RC4558_IMPL
D908 Net-_D908-Pad1_ Net-_D907-Pad1_ 1N4148
R917 PTC_RL PTC_IND 10k
D915 PTC_IND 0 LED_yellow
R906 PTC_OVSP Net-_D908-Pad1_ 100k
R903 PTC_OVSN PTC_REF 100k
R908 Net-_C903-Pad1_ 0 100k
R910 Net-_D907-Pad1_ Net-_R909-Pad1_ 10k
R909 Net-_R909-Pad1_ 0 1k
R911 Net-_D908-Pad1_ 0 15k
R907 VMOUT Net-_C903-Pad1_ 100k
C903 Net-_C903-Pad1_ 0 220uF
D906 -15V Net-_C903-Pad1_ 1N4148
D905 Net-_C903-Pad1_ +15V 1N4148
D904 PTC_OVSP Net-_D904-Pad2_ BAV21
Q902 Net-_D904-Pad2_ Net-_Q902-Pad2_ DRVN2 2N5551
D902 Net-_D902-Pad1_ PTC_OVSN BAV21
Q901 Net-_D902-Pad1_ Net-_Q901-Pad2_ DRVP2 2N5401
D901 VMOUT Net-_D901-Pad2_ 1N4734
R901 Net-_Q901-Pad2_ Net-_D901-Pad2_ 1k
R902 DRVP2 Net-_Q901-Pad2_ 22k
R904 Net-_D903-Pad1_ Net-_Q902-Pad2_ 1k
R905 Net-_Q902-Pad2_ DRVN2 22k
D903 Net-_D903-Pad1_ VMOUT 1N4734
C901 +15V 0 47uF
C902 0 -15V 47uF
.tran 0.1u 1m
.end
