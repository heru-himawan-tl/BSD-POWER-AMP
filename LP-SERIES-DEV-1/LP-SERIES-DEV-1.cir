.title 290W RMS FOR 4-OHMS CLASS-H AUDIO POWER AMPLIFIER - DEVELOPMENT STEP 1
.include "spice_models/model.lib"
V106 +24V 0 DC 24V
V107 0 -24V DC 24V
V104 +15V 0 DC 15V
V102 +63V 0 DC 63V
V103 0 -63V DC 63V
V105 0 -15V DC 15V
R_GND1 INPUT_GND 0 1
R_LOAD1 VPOUT 0 4
V101 MAIN_IN 0 dc 0 ac 1.44 sin(0 1.44 1k 0 0)
R604 Net-_Q601-Pad1_ -63V 1.5k
R601 Net-_R601-Pad1_ -63V 15k
R602 -24V Net-_R602-Pad2_ 10k
R603 -24V Net-_Q601-Pad3_ 1.5k
D602 Net-_R602-Pad2_ Net-_R601-Pad1_ BAV21
Q601 Net-_Q601-Pad1_ Net-_R602-Pad2_ Net-_Q601-Pad3_ 2N5401
D601 Net-_R601-Pad1_ VMOUT 1N4736
R607 Net-_Q605-Pad2_ Net-_R607-Pad2_ 1.5k
Q602 Net-_R606-Pad2_ Net-_Q601-Pad1_ Net-_R605-Pad1_ 2N5551
R608 Net-_Q605-Pad2_ -63V 1.5k
R605 Net-_R605-Pad1_ -63V 1.5k
Q603 Net-_Q605-Pad2_ Net-_R606-Pad2_ -24V 2N5401
R606 -24V Net-_R606-Pad2_ 1.5k
XQ601 L_VSW L_GCTL -63V IRF540
D603 L_VSW -24V MURF1560
Q604 0 Net-_R607-Pad2_ L_GCTL 2N5551
Q605 -63V Net-_Q605-Pad2_ L_GCTL 2N5401
D604 -63V Net-_R607-Pad2_ 1N4742
Q409 -63V VASN DRVN MJE15033
R409 0 Net-_D407-Pad1_ 47k
Q402 Net-_D404-Pad2_ Net-_D407-Pad1_ Net-_Q402-Pad3_ MJE340
Q406 VASN Net-_D413-Pad1_ VAS_EDN MJE340
R418 VAS_EDN -63V 220
R405 INPUT_GND 0 10
R417 Net-_D413-Pad2_ -63V 220
D413 Net-_D413-Pad1_ Net-_D413-Pad2_ 1N4007
R402 INPUT_GND REF 12k
R4042 NFB Net-_C403-Pad1_ 3.9k
R403 VMOUT NFB 12k
R4041 NFB Net-_C403-Pad1_ 390
C403 Net-_C403-Pad1_ INPUT_GND 220uF
C402 INPUT_GND REF 220pF
C411 0 -63V 0.1uF
C412 0 -63V 10uF
D407 Net-_D407-Pad1_ Net-_D407-Pad2_ 1N4007
R410 Net-_Q402-Pad3_ -63V 120
D408 Net-_D407-Pad2_ -63V 1N4007
XU401 unconnected-_U401-Pad1_ NFB REF -15V Net-_C404-Pad2_ OP +15V Net-_C404-Pad1_ NE5534
R401 Net-_C401-Pad2_ REF 390
C410 +63V 0 10uF
C401 MAIN_IN Net-_C401-Pad2_ 10uF
C409 +63V 0 0.1uF
R416 VASGCTLN VASN 12k
R415 Net-_D412-Pad2_ VASGCTLN 560
D412 0 Net-_D412-Pad2_ 1N4007
Q405 Net-_D413-Pad1_ Net-_D404-Pad2_ VASGCTLN MJE350
C407 VASN Net-_D413-Pad1_ 82pF
C406 VASP VASN 0.1uF
R422 VASP VBT 5k
RT401 VASP VBT 5k
R421 VBT VSB 560
R423 DRVP VMOUT 120
R424 VMOUT DRVN 120
R420 VASP VSB 560
R419 VSB VASN 1.2k
Q407 VASN VSB VASP MJE350
D411 VASGCTLP Net-_D411-Pad2_ 1N4007
D401 Net-_D401-Pad1_ Net-_D401-Pad2_ 1N4007
D402 Net-_D401-Pad2_ OP 1N4007
R406 Net-_D401-Pad1_ Net-_D404-Pad2_ 1k
D414 Net-_D411-Pad2_ VASGCTLN 1N4007
C404 Net-_C404-Pad1_ Net-_C404-Pad2_ 33pF
D403 OP Net-_D403-Pad2_ 1N4007
D404 Net-_D403-Pad2_ Net-_D404-Pad2_ 1N4007
Q408 +63V VASP DRVP MJE15032
R413 +63V Net-_D410-Pad1_ 220
D410 Net-_D410-Pad1_ Net-_D410-Pad2_ 1N4007
Q404 VASP Net-_D410-Pad2_ VAS_EDP MJE350
R414 +63V VAS_EDP 220
C405 VASP Net-_D410-Pad2_ 82pF
Q403 Net-_D410-Pad2_ Net-_D401-Pad1_ VASGCTLP MJE340
D409 Net-_D409-Pad1_ 0 1N4007
R411 VASGCTLP Net-_D409-Pad1_ 560
R412 VASP VASGCTLP 12k
R408 +63V Net-_Q401-Pad3_ 120
D406 +63V Net-_D405-Pad1_ 1N4007
R407 Net-_D405-Pad2_ 0 47k
Q401 Net-_D401-Pad1_ Net-_D405-Pad2_ Net-_Q401-Pad3_ MJE350
D405 Net-_D405-Pad1_ Net-_D405-Pad2_ 1N4007
Q410 H_VSW DRVP Net-_Q410-Pad3_ 2SC5200
R507 Net-_R506-Pad1_ H_VSW 1.5k
Q504 H_VSW Net-_R506-Pad1_ H_GCTL 2N5401
D701 Net-_D701-Pad1_ Net-_D701-Pad2_ 1N4753
R701 H_VSW Net-_D701-Pad2_ 22k
R702 H_VSW Net-_Q701-Pad1_ 22k
XQ501 +63V H_GCTL H_VSW IRF540
Q502 Net-_R506-Pad1_ Net-_R504-Pad2_ H_VBST 2N5401
R506 Net-_R506-Pad1_ Net-_R506-Pad2_ 1.5k
Q503 H_VBST Net-_R506-Pad2_ H_GCTL 2N5551
D507 H_VSW Net-_R506-Pad2_ 1N4742
C408 Net-_C408-Pad1_ 0 0.1uF
R427 VMOUT Net-_C408-Pad1_ 10
L401 VMOUT VPOUT 1uH
R426 VMOUT Net-_Q411-Pad3_ 0.12
Q411 L_VSW DRVN Net-_Q411-Pad3_ 2SA1943
R425 Net-_Q410-Pad3_ VMOUT 0.12
Q701 Net-_Q701-Pad1_ Net-_D701-Pad1_ L_VSW 2N5551
C501 Net-_R505-Pad2_ H_VSW 10uF
D504 H_VSW Net-_R505-Pad2_ 1N4749
R501 +63V Net-_D501-Pad2_ 15k
D506 +63V H_VBST 1N4007
D505 Net-_R505-Pad2_ H_VBST 1N4007
R505 +63V Net-_R505-Pad2_ 15k
R504 H_VBST Net-_R504-Pad2_ 1.5k
D502 Net-_D501-Pad2_ Net-_Q501-Pad2_ BAV21
Q501 Net-_R504-Pad2_ Net-_Q501-Pad2_ Net-_R503-Pad1_ 2N5551
D503 +24V H_VSW MURF1560
D415 DRVP H_VSW 1N4007
D416 L_VSW DRVN 1N4007
R502 Net-_Q501-Pad2_ +24V 10k
D501 VMOUT Net-_D501-Pad2_ 1N4736
R503 Net-_R503-Pad1_ +24V 1.5k
.tran 0.1u 3m 1m
.end
