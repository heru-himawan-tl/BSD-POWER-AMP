.title 1300W RMS FOR 4-OHMS CLASS-TD AUDIO POWER AMPLIFIER - DEVELOPMENT STEP 4
.include "spice_models/model.lib"
R_TMPL1 VPOUT LOAD_OUT 4
R_LOAD1 LOAD_OUT 0 4
V102 +120V 0 DC 120V
R_RELAY1 +24V PTC_RL 660
R_GND1 INPUT_GND 0 1
V105 0 -15V DC 15V
V103 0 -120V DC 120V
V104 +15V 0 DC 15V
V106 +24V 0 DC 24V
V101 MAIN_IN 0 dc 0 ac 1.44 sin(0 1.44 1k 0 0)
R4082 Net-_R4081-Pad2_ -120V 27
C410 0 -120V 10uF
Q405 DIFF_RE VMRRZ Net-_Q405-Pad3_ MJE340
R4081 Net-_Q405-Pad3_ Net-_R4081-Pad2_ 560
R4074 0 VMRRZ 82k
Q408 VASN VMRRZ Net-_Q408-Pad3_ MJE340
R4142 Net-_R4141-Pad2_ -120V 27
R4141 Net-_Q408-Pad3_ Net-_R4141-Pad2_ 560
R4073 0 VMRRZ 82k
R4072 0 VMRRZ 82k
D401 -120V VMRRZ 1N4730
C409 0 -120V 0.1uF
C407 +120V 0 0.1uF
RG401 INPUT_GND 0 10
D712 VSFN 0 MURF1560
R711 VSZPN VSFN 680
C704 0 VSAVN 1uF
D714 VSAVN 0 MURF1560
L701 VSFN VSAVN 10uH
R709 0 VSTAN 15k
Q4142 VSAVN DRVN2 Net-_Q4142-Pad3_ 2SA1943
R4192 VMOUT Net-_Q4142-Pad3_ 0.33
Q4143 VSAVN DRVN2 Net-_Q4143-Pad3_ 2SA1943
R4193 VMOUT Net-_Q4143-Pad3_ 0.33
Q4141 VSAVN DRVN2 Net-_Q4141-Pad3_ 2SA1943
R4191 VMOUT Net-_Q4141-Pad3_ 0.33
Q709 -120V Net-_Q708-Pad3_ VSGN MJE350
Q711 VSFN Net-_Q708-Pad3_ VSGN MJE340
D709 VSGZN VSLDRVN BAV21
D710 -120V VSGZN 1N4742
Q708 -120V VSLDRVN Net-_Q708-Pad3_ 2N5401
Q707 VSLDRVN VSTAN -120V 2N5551
Q710 VSFN VSGZN Net-_Q708-Pad3_ 2N5551
R707 VSTCN -120V 1.5
Q705 VSTCN VSTDRVN2 VSAVN 2SA1943
Q706 VSTAN Net-_Q706-Pad2_ -120V 2N5551
D708 VSTCN Net-_D707-Pad1_ MURF1560
D707 Net-_D707-Pad1_ -120V MURF1560
R708 VSTCN Net-_Q706-Pad2_ 150
Q4145 VSAVN DRVN2 Net-_Q4145-Pad3_ 2SA1943
R420 VMOUT Net-_C406-Pad1_ 10
Q4146 VSAVN DRVN2 Net-_Q4146-Pad3_ 2SA1943
R4196 VMOUT Net-_Q4146-Pad3_ 0.33
C406 Net-_C406-Pad1_ 0 0.1uF
R4195 VMOUT Net-_Q4145-Pad3_ 0.33
Q4144 VSAVN DRVN2 Net-_Q4144-Pad3_ 2SA1943
R4194 VMOUT Net-_Q4144-Pad3_ 0.33
R710 0 VSGZN 15k
D711 VSGZN VSFN BAV21
XQ7011 VSFN VSGN -120V IRFP250N
XQ7012 VSFN VSGN -120V IRFP250N
C703 VSAVN VSZPN 2200pF
D715 -120V VSAVN MURF1560
D713 -120V VSFN MURF1560
R4171 VMOUT DRVN2 8.2
R4161 DRVP2 VMOUT 8.2
Q411 VSAVP DRVP1 DRVP2 2SC5200
R605 +120V Net-_D605-Pad2_ 47k
Q603 +120V Net-_D605-Pad2_ Net-_D606-Pad1_ MJE340
Q604 +120V VSTDRVP1 VSTDRVP2 MJE15032
D606 Net-_D606-Pad1_ VSTDRVP1 1N4007
R606 VSTDRVP2 VSAVP 56
D604 Net-_D604-Pad1_ VSTDRVP1 1N4007
D605 0 Net-_D605-Pad2_ 1N4744
Q602 +120V Net-_C602-Pad2_ Net-_D604-Pad1_ MJE340
R604 VSTDRVP1 VSAVP 470
Q412 VSAVN DRVN1 DRVN2 2SA1943
D702 Net-_C701-Pad1_ DRVN2 BAV21
Q704 -120V VSTDRVN1 VSTDRVN2 MJE15033
R706 VSAVN VSTDRVN2 56
D706 VSTDRVN1 Net-_D706-Pad2_ 1N4007
Q703 -120V Net-_D705-Pad1_ Net-_D706-Pad2_ MJE350
Q702 -120V Net-_C702-Pad1_ Net-_D704-Pad2_ MJE350
R705 Net-_D705-Pad1_ -120V 47k
R704 VSAVN VSTDRVN1 470
D704 VSTDRVN1 Net-_D704-Pad2_ 1N4007
D705 Net-_D705-Pad1_ 0 1N4744
C602 +120V Net-_C602-Pad2_ 330pF
D603 Net-_D603-Pad1_ Net-_C602-Pad2_ 1N4734
Q601 0 Net-_C601-Pad2_ Net-_D603-Pad1_ 2N5401
C702 Net-_C702-Pad1_ -120V 330pF
R701 Net-_D701-Pad2_ -120V 1.5k
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
R702 Net-_C702-Pad1_ Net-_C701-Pad2_ 47k
Q701 0 Net-_C701-Pad1_ Net-_D703-Pad2_ 2N5551
D703 Net-_C702-Pad1_ Net-_D703-Pad2_ 1N4734
C701 Net-_C701-Pad1_ Net-_C701-Pad2_ 10uF
R703 0 Net-_C701-Pad1_ 47k
Q410 -120V VASN DRVN1 MJE15033
Q4131 VSAVP DRVP2 Net-_Q4131-Pad3_ 2SC5200
Q4132 VSAVP DRVP2 Net-_Q4132-Pad3_ 2SC5200
R4183 Net-_Q4133-Pad3_ VMOUT 0.33
Q4133 VSAVP DRVP2 Net-_Q4133-Pad3_ 2SC5200
R4181 Net-_Q4131-Pad3_ VMOUT 0.33
R609 Net-_D609-Pad1_ 0 15k
R610 VSLDRVP 0 15k
R4182 Net-_Q4132-Pad3_ VMOUT 0.33
XQ6012 +120V VSGP VSFP IRFP250N
R612 VSFP VSZPP 680
D612 0 VSFP MURF1560
C603 VSZPP VSAVP 2200pF
D613 VSFP +120V MURF1560
D615 VSAVP +120V MURF1560
L601 VSFP VSAVP 10uH
XQ6011 +120V VSGP VSFP IRFP250N
D614 0 VSAVP MURF1560
C604 VSAVP 0 1uF
Q609 VSFP Net-_Q608-Pad3_ VSGP MJE350
Q610 +120V VSGZP Net-_Q608-Pad3_ 2N5551
Q611 +120V Net-_Q608-Pad3_ VSGP MJE340
Q608 VSFP VSLDRVP Net-_Q608-Pad3_ 2N5401
R611 VSLDRVP VSGZP 1.5k
D611 VSFP VSGZP 1N4742
D610 VSFP VSLDRVP BAV21
R4185 Net-_Q4135-Pad3_ VMOUT 0.33
R4184 Net-_Q4134-Pad3_ VMOUT 0.33
Q4134 VSAVP DRVP2 Net-_Q4134-Pad3_ 2SC5200
R4186 Net-_Q4136-Pad3_ VMOUT 0.33
L401 VMOUT VPOUT 1uH
Q4136 VSAVP DRVP2 Net-_Q4136-Pad3_ 2SC5200
Q4135 VSAVP DRVP2 Net-_Q4135-Pad3_ 2SC5200
R607 +120V VSTCP 1.5
Q605 VSTCP VSTDRVP2 VSAVP 2SC5200
R608 Net-_Q606-Pad2_ VSTCP 150
D608 Net-_D607-Pad2_ VSTCP MURF1560
D607 +120V Net-_D607-Pad2_ MURF1560
D609 Net-_D609-Pad1_ +120V 1N4742
Q606 VSTAP Net-_Q606-Pad2_ +120V 2N5401
Q607 VSLDRVP Net-_D609-Pad1_ VSTAP 2N5401
R4052 +120V Net-_Q403-Pad3_ 2.2k
R4051 +120V Net-_Q403-Pad3_ 100
R4061 +120V Net-_Q404-Pad3_ 100
Q404 DIFF_P DIFF_N Net-_Q404-Pad3_ MPSA92
Q403 DIFF_N DIFF_N Net-_Q403-Pad3_ MPSA92
R4071 0 VMRRZ 82k
Q407 VASN Net-_Q407-Pad2_ VASP MJE350
R410 Net-_Q407-Pad2_ VASN 2k
R411 VASP Net-_Q407-Pad2_ 680
R4151 DRVP1 DRVN1 200
C405 VASP VASN 0.1uF
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 680
RT401 VASP Net-_R412-Pad1_ 5k
R413 VASP Net-_R412-Pad1_ 2k
R4031 VMOUT NFB 22k
C404 VASP DIFF_P 220pF
R601 +120V Net-_D601-Pad1_ 1.5k
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
C601 Net-_C601-Pad1_ Net-_C601-Pad2_ 10uF
R602 Net-_C601-Pad1_ Net-_C602-Pad2_ 47k
R4091 +120V VAS_ED 220
R4092 +120V VAS_ED 3.3k
Q409 +120V VASP DRVP1 MJE15032
Q406 VASP DIFF_P VAS_ED MJE350
R603 Net-_C601-Pad2_ 0 47k
D602 DRVP2 Net-_C601-Pad2_ BAV21
R4062 +120V Net-_Q404-Pad3_ 2.2k
Q402 DIFF_N NFB DIFF_RE MPSA42
R4021 INPUT_GND REF 22k
C408 +120V 0 10uF
Q401 DIFF_P REF DIFF_RE MPSA42
C402 INPUT_GND REF 220pF
R401 Net-_C401-Pad2_ REF 820
R4041 NFB Net-_C403-Pad1_ 300
C403 Net-_C403-Pad1_ INPUT_GND 220uF
C401 MAIN_IN Net-_C401-Pad2_ 10uF
S901 LOAD_OUT VPOUT +24V PTC_RL sw1 ON
R915 Net-_D911-Pad2_ PTC_REF 100k
D911 Net-_C904-Pad2_ Net-_D911-Pad2_ 1N4148
R916 PTC_OP Net-_D913-Pad2_ 4.7k
D914 PTC_RL +24V 1N4002
D910 PTC_REF +15V 1N4148
D907 Net-_D907-Pad1_ PTC_REF 1N4148
Q903 PTC_RL Net-_D913-Pad2_ 0 TIP41C
C904 PTC_RL Net-_C904-Pad2_ 10uF
D912 0 Net-_C904-Pad2_ 1N4148
D913 0 Net-_D913-Pad2_ 1N4148
R913 Net-_R912-Pad2_ PTC_REF 470
R912 +15V Net-_R912-Pad2_ 15k
R914 PTC_REF -15V 15k
D909 -15V Net-_D908-Pad1_ 1N4148
XU901 Net-_D907-Pad1_ Net-_R909-Pad1_ Net-_C903-Pad1_ -15V Net-_D908-Pad1_ PTC_REF PTC_OP +15V RC4558_IMPL
D908 Net-_D908-Pad1_ Net-_D907-Pad1_ 1N4148
R917 PTC_RL PTC_IND 10k
D915 PTC_IND 0 LED_yellow
R906 PTC_OVSP Net-_D908-Pad1_ 100k
R903 PTC_OVSN PTC_REF 100k
R908 Net-_C903-Pad1_ 0 100k
R910 Net-_D907-Pad1_ Net-_R909-Pad1_ 10k
R909 Net-_R909-Pad1_ 0 1k
R911 Net-_D908-Pad1_ 0 15k
R907 VMOUT Net-_C903-Pad1_ 100k
C903 Net-_C903-Pad1_ 0 220uF
D906 -15V Net-_C903-Pad1_ 1N4148
D905 Net-_C903-Pad1_ +15V 1N4148
D904 PTC_OVSP Net-_D904-Pad2_ BAV21
Q902 Net-_D904-Pad2_ Net-_Q902-Pad2_ DRVN2 2N5551
D902 Net-_D902-Pad1_ PTC_OVSN BAV21
Q901 Net-_D902-Pad1_ Net-_Q901-Pad2_ DRVP2 2N5401
D901 VMOUT Net-_D901-Pad2_ 1N4734
R901 Net-_Q901-Pad2_ Net-_D901-Pad2_ 1k
R902 DRVP2 Net-_Q901-Pad2_ 22k
R904 Net-_D903-Pad1_ Net-_Q902-Pad2_ 1k
R905 Net-_Q902-Pad2_ DRVN2 22k
D903 Net-_D903-Pad1_ VMOUT 1N4734
C901 +15V 0 47uF
C902 0 -15V 47uF
.tran 0.1u 1m
.end
