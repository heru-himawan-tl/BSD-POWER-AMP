.title 1300W RMS FOR 4-OHMS CLASS-TD AUDIO POWER AMPLIFIER - DEVELOPMENT STEP 4
.include "spice_models/model.lib"
R_TMPL1 VPOUT LOAD_OUT 4
R_GND1 INPUT_GND 0 1
V101 MAIN_IN 0 dc 0 ac 1.44 sin(0 1.44 1k 0 0)
R_LOAD1 LOAD_OUT 0 4
V102 +120V 0 DC 120V
V105 0 -15V DC 15V
V103 0 -120V DC 120V
V106 +24V 0 DC 24V
V104 +15V 0 DC 15V
R_RELAY1 +24V PTC_RL 660
Q412 VSAVN DRVN1 DRVN2 2SA1943
R4171 DRVN2 VMOUT 8.2
R4161 VMOUT DRVP2 8.2
Q703 -120V Net-_D705-Pad1_ Net-_D706-Pad2_ MJE350
R705 Net-_D705-Pad1_ -120V 47k
D707 Net-_D707-Pad1_ -120V MURF1560
D708 VSTCN Net-_D707-Pad1_ MURF1560
Q704 -120V VSTDRVN1 VSTDRVN2 MJE15033
D706 VSTDRVN1 Net-_D706-Pad2_ 1N4007
D705 Net-_D705-Pad1_ 0 1N4744
Q701 0 Net-_C701-Pad1_ Net-_D703-Pad2_ 2N5551
R706 VSAVN VSTDRVN2 56
D702 Net-_C701-Pad1_ DRVN2 1N4007
R703 Net-_C701-Pad1_ 0 47k
R704 VSAVN VSTDRVN1 470
C702 -120V Net-_C702-Pad2_ 330pF
R702 Net-_C701-Pad2_ Net-_C702-Pad2_ 47k
C701 Net-_C701-Pad1_ Net-_C701-Pad2_ 10uF
D704 VSTDRVN1 Net-_D704-Pad2_ 1N4007
D703 Net-_C702-Pad2_ Net-_D703-Pad2_ 1N4734
Q702 -120V Net-_C702-Pad2_ Net-_D704-Pad2_ MJE350
D701 Net-_C701-Pad2_ Net-_D701-Pad2_ 1N4007
R701 Net-_D701-Pad2_ -120V 1.5k
D712 -120V VSFN MURF1560
D714 -120V VSAVN MURF1560
XQ7012 VSFN VSGN -120V IRFP250N
R711 VSFN VSZPN 680
C703 VSAVN VSZPN 2200pF
XQ7011 VSFN VSGN -120V IRFP250N
D709 VSGZN VSLDRVN 1N4007
D710 -120V VSGZN 1N4742
Q709 -120V Net-_Q708-Pad3_ VSGN MJE350
Q711 VSFN Net-_Q708-Pad3_ VSGN MJE340
Q708 -120V VSLDRVN Net-_Q708-Pad3_ 2N5401
Q710 VSFN VSGZN Net-_Q708-Pad3_ 2N5551
Q707 VSLDRVN VSTAN -120V 2N5551
C406 0 Net-_C406-Pad2_ 0.1uF
R4195 VMOUT Net-_Q4145-Pad3_ 0.33
Q4146 VSAVN DRVN2 Net-_Q4146-Pad3_ 2SA1943
R4196 VMOUT Net-_Q4146-Pad3_ 0.33
R420 VMOUT Net-_C406-Pad2_ 10
R710 VSGZN 0 15k
D711 VSFN 0 MURF1560
R709 VSTAN 0 15k
R707 VSTCN -120V 1.5
Q705 VSTCN VSTDRVN2 VSAVN 2SA1943
R708 VSTCN Net-_Q706-Pad2_ 150
Q706 VSTAN Net-_Q706-Pad2_ -120V 2N5551
Q4142 VSAVN DRVN2 Net-_Q4142-Pad3_ 2SA1943
R4193 VMOUT Net-_Q4143-Pad3_ 0.15
R4194 VMOUT Net-_Q4144-Pad3_ 0.33
Q4144 VSAVN DRVN2 Net-_Q4144-Pad3_ 2SA1943
R4192 VMOUT Net-_Q4142-Pad3_ 0.33
Q4143 VSAVN DRVN2 Net-_Q4143-Pad3_ 2SA1943
Q4145 VSAVN DRVN2 Net-_Q4145-Pad3_ 2SA1943
XQ6011 +120V VSGP VSFP IRFP250N
XQ6012 +120V VSGP VSFP IRFP250N
D613 VSFP +120V MURF1560
D615 VSAVP +120V MURF1560
C603 VSAVP VSZPP 2200pF
R612 VSFP VSZPP 680
L601 VSAVP VSFP 10uH
R4186 Net-_Q4136-Pad3_ VMOUT 0.33
L401 VPOUT VMOUT 1uH
Q4134 VSAVP DRVP2 Net-_Q4134-Pad3_ 2SC5200
Q4136 VSAVP DRVP2 Net-_Q4136-Pad3_ 2SC5200
R4185 Net-_Q4135-Pad3_ VMOUT 0.33
R4184 Net-_Q4134-Pad3_ VMOUT 0.33
Q4135 VSAVP DRVP2 Net-_Q4135-Pad3_ 2SC5200
R610 VSLDRVP 0 15k
D612 0 VSFP MURF1560
D713 VSAVN 0 MURF1560
C604 0 VSAVP 1uF
C704 VSAVN 0 1uF
D614 0 VSAVP MURF1560
L701 VSAVN VSFN 10uH
Q610 +120V VSGZP Net-_Q608-Pad3_ 2N5551
Q608 VSFP VSLDRVP Net-_Q608-Pad3_ 2N5401
Q611 +120V Net-_Q608-Pad3_ VSGP MJE340
Q609 VSFP Net-_Q608-Pad3_ VSGP MJE350
Q606 VSTAP Net-_Q606-Pad2_ +120V 2N5401
Q607 VSLDRVP Net-_R609-Pad1_ VSTAP 2N5401
R611 VSGZP VSLDRVP 1.5k
D610 VSFP VSLDRVP 1N4007
D611 VSFP VSGZP 1N4742
R4062 +120V Net-_Q404-Pad3_ 2.2k
R4061 +120V Net-_Q404-Pad3_ 100
C407 0 +120V 0.1uF
R4011 REF Net-_C401-Pad1_ 820
R4021 REF INPUT_GND 22k
C408 +120V 0 10uF
Q404 DIFF_P DIFF_N Net-_Q404-Pad3_ MPSA92
R4052 +120V Net-_Q403-Pad3_ 2.2k
R4051 +120V Net-_Q403-Pad3_ 100
R4091 +120V VAS_ED 220
Q406 VASP DIFF_P VAS_ED MJE350
C404 DIFF_P VASP 220pF
Q403 DIFF_N DIFF_N Net-_Q403-Pad3_ MPSA92
RG401 INPUT_GND 0 10
Q402 DIFF_N NFB DIFF_RE MPSA42
Q401 DIFF_P REF DIFF_RE MPSA42
R4031 VMOUT NFB 22k
R4041 NFB Net-_C403-Pad1_ 300
C403 Net-_C403-Pad1_ INPUT_GND 220uF
R4082 Net-_R4081-Pad2_ -120V 27
C410 0 -120V 10uF
C402 INPUT_GND REF 220pF
R4081 Net-_Q405-Pad3_ Net-_R4081-Pad2_ 560
Q405 DIFF_RE VMRRZ Net-_Q405-Pad3_ MJE340
RT401 VASP Net-_R412-Pad1_ 5k
R412 Net-_R412-Pad1_ Net-_Q407-Pad2_ 680
C401 Net-_C401-Pad1_ MAIN_IN 10uF
Q408 VASN VMRRZ Net-_Q408-Pad3_ MJE340
R4073 0 VMRRZ 82k
R4072 0 VMRRZ 82k
R4071 0 VMRRZ 82k
R4074 0 VMRRZ 82k
C409 -120V 0 0.1uF
R4141 Net-_Q408-Pad3_ Net-_R4141-Pad2_ 560
R4142 Net-_R4141-Pad2_ -120V 27
Q410 -120V VASN DRVN1 MJE15033
D401 -120V VMRRZ 1N4730
R410 Net-_Q407-Pad2_ VASN 2k
R411 Net-_Q407-Pad2_ VASP 680
R413 VASP Net-_R412-Pad1_ 2k
R4151 DRVN1 DRVP1 200
Q409 +120V VASP DRVP1 MJE15032
C405 VASN VASP 0.1uF
Q407 VASN Net-_Q407-Pad2_ VASP MJE350
R4092 +120V VAS_ED 3.3k
D604 Net-_D604-Pad1_ VSTDRVP1 1N4007
Q602 +120V Net-_C602-Pad1_ Net-_D604-Pad1_ MJE340
D603 Net-_D603-Pad1_ Net-_C602-Pad1_ 1N4734
R601 +120V Net-_D601-Pad1_ 1.5k
D601 Net-_D601-Pad1_ Net-_C601-Pad1_ 1N4007
C602 Net-_C602-Pad1_ +120V 330pF
C601 Net-_C601-Pad1_ Net-_C601-Pad2_ 10uF
R602 Net-_C601-Pad1_ Net-_C602-Pad1_ 47k
R4183 Net-_Q4133-Pad3_ VMOUT 0.33
Q4133 VSAVP DRVP2 Net-_Q4133-Pad3_ 2SC5200
Q4132 VSAVP DRVP2 Net-_Q4132-Pad3_ 2SC5200
R4182 Net-_Q4132-Pad3_ VMOUT 0.33
R606 VSTDRVP2 VSAVP 56
R609 Net-_R609-Pad1_ 0 15k
R603 Net-_C601-Pad2_ 0 47k
D602 DRVP2 Net-_C601-Pad2_ 1N4007
Q601 0 Net-_C601-Pad2_ Net-_D603-Pad1_ 2N5401
R604 VSTDRVP1 VSAVP 470
R605 +120V Net-_D605-Pad2_ 47k
Q603 +120V Net-_D605-Pad2_ Net-_D606-Pad1_ MJE340
D606 Net-_D606-Pad1_ VSTDRVP1 1N4007
D605 0 Net-_D605-Pad2_ 1N4744
R4181 Net-_Q4131-Pad3_ VMOUT 0.33
Q4131 VSAVP DRVP2 Net-_Q4131-Pad3_ 2SC5200
Q411 VSAVP DRVP1 DRVP2 2SC5200
Q4141 VSAVN DRVN2 Net-_Q4141-Pad3_ 2SA1943
R4191 VMOUT Net-_Q4141-Pad3_ 0.33
Q604 +120V VSTDRVP1 VSTDRVP2 MJE15032
Q605 VSTCP VSTDRVP2 VSAVP 2SC5200
R608 VSTCP Net-_Q606-Pad2_ 150
D608 Net-_D607-Pad2_ VSTCP MURF1560
D607 +120V Net-_D607-Pad2_ MURF1560
D609 Net-_R609-Pad1_ +120V 1N4742
R607 +120V VSTCP 1.5
R917 PTC_RL PTC_IND 10k
Q903 PTC_RL Net-_D913-Pad2_ 0 TIP41C
C904 PTC_RL Net-_C904-Pad2_ 10uF
D914 PTC_RL +24V 1N4002
S901 LOAD_OUT VMOUT +24V PTC_RL sw1 ON
D915 PTC_IND 0 LED_yellow
Q901 Net-_D902-Pad1_ Net-_Q901-Pad2_ DRVP2 2N5401
R902 DRVP2 Net-_Q901-Pad2_ 22k
D903 Net-_D903-Pad1_ VMOUT 1N4734
R904 Net-_D903-Pad1_ Net-_Q902-Pad2_ 1k
D901 VMOUT Net-_D901-Pad2_ 1N4734
R901 Net-_Q901-Pad2_ Net-_D901-Pad2_ 1k
Q902 Net-_D904-Pad2_ Net-_Q902-Pad2_ DRVN2 2N5551
R905 Net-_Q902-Pad2_ DRVN2 22k
XU901 Net-_D907-Pad1_ Net-_R909-Pad2_ Net-_C903-Pad1_ -15V Net-_D908-Pad1_ PTC_REF PTC_OP +15V RC4558_IMPL
C901 +15V 0 47uF
C902 0 -15V 47uF
R912 +15V Net-_R912-Pad2_ 15k
R913 Net-_R912-Pad2_ PTC_REF 470
R914 -15V PTC_REF 15k
D902 Net-_D902-Pad1_ PTC_OVSN BAV21
R903 PTC_OVSN PTC_REF 100k
R916 Net-_D913-Pad2_ PTC_OP 4.7k
D909 -15V Net-_D908-Pad1_ 1N4148
D912 0 Net-_C904-Pad2_ 1N4148
D913 0 Net-_D913-Pad2_ 1N4148
D911 Net-_C904-Pad2_ Net-_D911-Pad2_ 1N4148
R915 PTC_REF Net-_D911-Pad2_ 100k
D908 Net-_D908-Pad1_ Net-_D907-Pad1_ 1N4148
D907 Net-_D907-Pad1_ PTC_REF 1N4148
D910 PTC_REF +15V 1N4148
R906 PTC_OVSP Net-_D908-Pad1_ 100k
D904 PTC_OVSP Net-_D904-Pad2_ BAV21
D905 Net-_C903-Pad1_ +15V 1N4148
R911 0 Net-_D908-Pad1_ 15k
R909 0 Net-_R909-Pad2_ 1k
R910 Net-_R909-Pad2_ Net-_D907-Pad1_ 10k
R907 VMOUT Net-_C903-Pad1_ 100k
R908 0 Net-_C903-Pad1_ 100k
C903 Net-_C903-Pad1_ 0 220uF
D906 -15V Net-_C903-Pad1_ 1N4148
.tran 0.1u 1m
.print tran v(VSFP) v(VSFN) v(VSAVP) v(VSAVN) v(VMOUT)
.end
